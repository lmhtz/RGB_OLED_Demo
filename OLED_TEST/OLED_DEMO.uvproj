# Keil uVision project OLED_DEMO.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC12C5A60S2 STC
  cpu: IRAM(0-0xFF) XRAM(0-0x3FF) IROM(0-0xEFFF) CLOCK(45000000) MODP2
  output: OLED_DEMO +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: STARTUP.A51 delay.c main.c ssd1332.c iic.c myfun.c pcf8563.c uart.c PWM_SOFT.C
